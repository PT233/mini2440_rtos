# Keil uVision project ucosii.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: ucosii +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\archcopy;.\drivers;.\include;.\kernel;.\lib;.\user
  asm include: .\drivers;.\include;.\kernel;.\lib;.\user;.\archcopy
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\Objects\ucosii.sct
  link misc: --entry _start --datacompressor=off
  group include
    ./include/: 2440addr.h 2440addr.inc includes.h memcfg.inc os_cfg.h os_cpu.h os_timer.h os_uart.h ucos_ii.h
  group drivers
    ./drivers/: os_bsp.c os_timer.c os_uart.c
  group kernel
    ./kernel/: os.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group lib
    ./lib/: os_lib.c
  group user
    ./user/: main.c
  group arch_keil
    ./archcopy/: os_cpu_cs_keil.S os_cpu_init.c startup_keil.S
