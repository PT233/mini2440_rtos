# Keil uVision project mini2440rtos.uvproj, settings and files
target simulator (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: mini2440rtos +hex
  AfterMake: fromelf --bin .\Objects\mini2440rtos.axf --output .\Objects\mini2440rtos.bin
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\arch_keil;.\drivers;.\include;.\kernel;.\lib;.\user
  memory RVCT4: ROM 0x30000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\s3c2440_sim.sct
  link misc: --map --entry _start
  group include
    ./include/: 2440addr.h 2440addr.inc includes.h memcfg.inc os_cfg.h os_cpu.h os_timer.h os_uart.h ucos_ii.h
  group arch_keil
    ./arch_keil/: os_cpu_cs_keil.S os_cpu_init.c startup_keil.S startup_keil_sim.S
  group user
    ./user/: main.c
  group lib
    ./lib/: os_lib.c
  group kernel
    ./kernel/: os.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group drivers
    ./drivers/: os_bsp.c os_timer.c os_uart.c
target board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: mini2440rtos +hex
  AfterMake: as above
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\arch_keil;.\drivers;.\include;.\kernel;.\lib;.\user
  memory RVCT4: ROM 0x30000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\s3c2440.sct
  link misc: --map --entry Reset_Handler
