# Keil uVision project mini2440_rtos.uvprojx, settings and files
target mini2440_rtos (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: mini2440_rtos +hex
  c flags: OneElfS=1 v6LangP=1 wLevel=2
  c misc: -O0 -g --cpu=ARM920T
  c include: ..\include;
                ..\arch\inc;
                ..\user\inc;
                ..\drivers\inc;
                ..\kernel;
                ..\arch_keil
  asm define: as above
  asm misc: --cpu=ARM920T
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\s3c2440.sct
  group arch_keil
    ../arch_keil/: startup_keil.S os_cpu_cs_keil.S os_cpu_init.c
  group user
    ../user/: main.c
  group drivers
    ../drivers/: os_bsp.c os_uart.c os_timer.c
  group kernel
    ../kernel/: os.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group lib
    ../lib/: os_lib.c
